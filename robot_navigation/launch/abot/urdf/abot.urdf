Commit message: Added python path planners to workspace.

File: robot_navigation/launch/abot/urdf/abot.urdf (robot description, URDF)
Before this commit: robot abot, 2 links, 1 joints
Joints:
- joint base_to_laser: origin xyz=0.14 0 0.295 rpy=0 0 0 -> xyz=0.28 0 0.295 rpy=0 0 0
